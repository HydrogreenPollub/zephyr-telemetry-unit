## boards/hydrogreen/telemetry_unit/board.yml
```yaml
board:
  name: telemetry_unit
  full_name: Telemetry Unit
  vendor: hydrogreen
  socs:
    - name: stm32g491xx
```
